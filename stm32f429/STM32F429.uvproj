# Keil uVision project STM32F429.uvproj, settings and files
target STM32F429 (ARM-ADS)
  device: STM32F429IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F429 +hex
  c define: USE_USB_OTG_FS HSE_VALUE=25000000 STM32F429XX
  c include: ..\..\cortex4\includ;..\..\ARM\ARMCC\include;..\incl;..\..\ARM\Startup;..\STM32F4xx_HAL_Driver\Inc;..\STM32F4xx_HAL_Driver\re_incl;..\STM32F4xx_HAL_Driver\CMSIS\Device\ST\STM32F4xx\Include;..\STM32F4xx_HAL_Driver\CMSIS\Include;..\RSTP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0xc0000000 size 0x1000000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: STM32F429.sct
  group source
    ./: startup_stm32f429x.s
    ../STM32F4xx_HAL_Driver/re_src/: system_stm32f4xx.c
  group main
    ../STM32F4xx_HAL_Driver/re_src/: stm32f4xx_it.c
    ../scr_code/: main.c veth_com_usart.c veth_eth_ap.c veth_hal_init.c veth_m_4pse.c veth_marvell_6097f.c veth_system_clock.c veth_ntoh.c veth_RSTP.c veth_nor.c veth_sdram.c veth_InVariate.c
  group RSTP
    ../RSTP/src/: edge.c migrate.c p2p.c pcost.c port.c portinfo.c rolesel.c roletrns.c statmch.c stp_in.c stp_to.c stpm.c sttrans.c times.c topoch.c transmit.c vector.c
  group firmware
    ../STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_eth.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sdram.c stm32f4xx_ll_fmc.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_nor.c
