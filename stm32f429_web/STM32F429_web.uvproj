# Keil uVision project STM32F429_web.uvproj, settings and files
target STM32F429_web (ARM-ADS)
  device: STM32F429IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F429_web +hex
  AfterMake: D:\KEIL\ARM\ARMCC\bin\fromelf.exe --bin --output C:\Users\Allen\Desktop\bin\VETH1.vImage  .\HEX\STM32F429_web.axf
  c flags: Optim=1 wLevel=1
  c include: ..\..\cortex4\includ;..\..\ARM\ARMCC\include;..\incl;..\..\ARM\Startup;..\STM32F4xx_HAL_Driver\Inc;..\STM32F4xx_HAL_Driver\re_incl;..\STM32F4xx_HAL_Driver\CMSIS\Device\ST\STM32F4xx\Include;..\STM32F4xx_HAL_Driver\CMSIS\Include;..\RSTP\inc;..\scr_code\cgi\incl;..\lwip\lwip_incl;..\webserver\webserver_incl;..\ntp\ntp_incl;..\JSON\JSON_inc;..\Utility\Utility_incl;..\systemlog\systemlog_inc;..\session\session_incl;..\serialclient\serialclient_incl;..\serialutility\serialutility_incl;..\serialserver\serialserver_incl;..\multicast\multicast_inc
  asm include: ..\..\ARM\ARMCC\include;..\incl;..\..\ARM\Startup;..\STM32F4xx_HAL_Driver\re_incl;..\STM32F4xx_HAL_Driver\CMSIS\Device\ST\STM32F4xx\Include;..\STM32F4xx_HAL_Driver\CMSIS\Include;..\RSTP\inc;..\scr_code\cgi\incl;..\lwip\lwip_incl;..\webserver\webserver_incl;..\ntp\ntp_incl;..\JSON\JSON_inc;..\Utility\Utility_incl;..\systemlog\systemlog_inc;..\session\session_incl;..\serialclient\serialclient_incl;..\serialutility\serialutility_incl;..\serialserver\serialserver_incl;..\multicast\multicast_inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: STM32F429_web.sct
  group Startup
    ./: startup_stm32f429x.s
    ../STM32F4xx_HAL_Driver/re_src/: system_stm32f4xx.c
  group main
    ../scr_code/: main.c veth_com_usart.c veth_eth_ap.c veth_hal_init.c veth_InVariate.c veth_m_4pse.c veth_marvell_6097f.c veth_sdram.c veth_system_clock.c veth_RSTP.c veth_ntoh.c veth_serial.c FIFO.c
    ../STM32F4xx_HAL_Driver/re_src/: stm32f4xx_it.c
  group RSTP
    ../RSTP/src/: edge.c migrate.c p2p.c pcost.c port.c portinfo.c rolesel.c roletrns.c statmch.c stp_in.c stp_to.c stpm.c sttrans.c times.c topoch.c transmit.c vector.c
  group cgi
    ../scr_code/: veth_netupgrade.c
    ../scr_code/cgi/src/: veth_mac.c veth_port.c veth_vlan.c veth_COM.c
  group Firmware
    ../STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_nor.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_iwdg.c
  group lwip
    ../lwip/lwip_src/: asn1_dec.c asn1_enc.c autoip.c def.c dhcp.c dns.c igmp.c inet.c init.c mib_structs.c mib2.c msg_in.c msg_out.c slipif.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c etharp.c ethernetif.c icmp.c inet_chksum.c ip.c ip_addr.c ip_frag.c mem.c memp.c netif.c pbuf.c raw.c
  group webserver
    ../webserver/webserver_src/: board_info.c fs.c web_main.c ip_config.c crc16.c httpd.c httpd-cgi.c ports.c request.c timer.c system_maintain.c gbk_conv_hanzi.c system_info.c mac_link.c mac_table.c mac.c vlan.c vlan_link.c user.c
  group ntp
    ../ntp/ntp_src/: ntp_client.c
  group JSON
    ../JSON/JSON_src/: cJSON.c JSONUtility.c
  group Utility
    ../Utility/Utility_src/: upload_file.c FindSubstring.c StringHashTable.c Utility.c
  group systemlog
    ../systemlog/systemlog_src/: LogInfo.c LogUtility.c
  group session
    ../session/session_src/: Session.c
  group SerialUtility
    ../serialutility/serialutility_src/: SerialQueue.c SerialUtility.c
  group SerialClient
    ../serialclient/serialclient_src/: SerialClient.c SerialClientUdp.c
  group SerialServer
    ../serialserver/serialserver_src/: SerialServer.c SerialServerUdp.c
  group Multicast
    ../multicast/multicast_src/: MulticastUtility.c
