# Keil uVision project STM32F407.uvproj, settings and files
target stm32f407 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F407 +hex
  c flags: Optim=1
  c define: STM32F4XX MANGUSTA_DISCOVERY USE_USB_OTG_FS HSE_VALUE=8000000 STM32F407XX
  c include: ..\..\cortex4\includ;..\..\ARM\ARMCC\include;..\incl;..\..\ARM\Startup;..\STM32F4xx_HAL_Driver\Inc;..\STM32F4xx_HAL_Driver\re_incl;..\STM32F4xx_HAL_Driver\CMSIS\Device\ST\STM32F4xx\Include;..\STM32F4xx_HAL_Driver\CMSIS\Include;..\RSTP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --libpath=D:\ProgramFiles\KEIL\ARM\ARMCC\lib
  group souce
    ../STM32F4xx_HAL_Driver/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    ../STM32F4xx_HAL_Driver/re_src/: system_stm32f4xx.c
  group main
    ../STM32F4xx_HAL_Driver/re_src/: system_clock.c hal_init.c stm32f4xx_it.c eth_ap.c
    ../: main1.c
    ../scr_code/: marvell_6097f.c com_usart.c big_little.c i2c.c m_4pse.c
  group firmware
    ../STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_hal_eth.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c
  group RSTP
    ../RSTP/src/: edge.c migrate.c p2p.c pcost.c port.c portinfo.c rolesel.c roletrns.c statmch.c stp_in.c stp_to.c stpm.c sttrans.c times.c topoch.c transmit.c vector.c
